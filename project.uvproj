# Keil uVision project project.uvproj, settings and files
target STM322xGMiniSystem_UCOSII (ARM-ADS)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xGMiniSystem
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: .\src\main\include;.\src\dsrc\include;.\src\driver\gpio;.\src\driver\nvic;.\src\driver\adc;.\src\driver\can;.\src\driver\fsmc;.\src\driver\i2c;.\src\driver\spi;.\src\driver\tim;.\src\driver\usart;.\src\STM32F2xxLibraries\CMSIS\CM3\CoreSupport;.\src\STM32F2xxLibraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;.\src\STM32F2xxLibraries\STM32F2xx_StdPeriph_Driver\inc;.\src\driver\exti;.\src\tcp_ip\inc;.\src\lwip_v1.3.2\src\include;.\src\lwip_v1.3.2\src\include\lwip;.\src\lwip_v1.3.2\src\include\netif;.\src\lwip_v1.3.2\src\include\ipv4;.\src\lwip_v1.3.2\port\STM32F2x7;.\src\lwip_v1.3.2\port\STM32F2x7\Standalone;.\src\STM32F2xxLibraries\STM32F2x7_ETH_Driver\inc;.\src\ucosii\Source;.\src\ucosii_port\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ./src/main/: main.c stm32f2xx_it.c system_stm32f2xx.c public.c app.c
  group Driver
    ./src/driver/adc/: adc.c
    ./src/driver/gpio/: gpio.c
    ./src/driver/spi/: spi.c
    ./src/driver/tim/: tim.c
    ./src/driver/usart/: usart.c smartcard.c
    ./src/driver/can/: can.c
    ./src/driver/fsmc/: fsmc.c
    ./src/driver/i2c/: i2c.c
    ./src/driver/exti/: exti.c
  group Startup
    ./src/main/: startup_stm32f2xx.s
  group CMSIS
    ./src/STM32F2xxLibraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32F2xx_StdPeriph_Driver
    ./src/STM32F2xxLibraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group STM32F2xx_ETH_Driver
    ./src/STM32F2xxLibraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group lwip1.3.2
    ./src/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./src/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./src/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./src/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ./src/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group tcp_ip
    ./src/tcp_ip/src/: netconf.c serial_debug.c stm32f2x7_eth_bsp.c phy.c tcp_ip.c tcp_server.c tcp_server1.c tcp_server2.c
  group ucosii
    ./src/ucosii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos_port
    ./src/ucosii_port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
